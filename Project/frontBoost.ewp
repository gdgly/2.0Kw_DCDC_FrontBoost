# IAR project frontBoost.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCDiagSuppress: Pa050,Pe940
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM8S_StdPeriph_Driver\inc; ..\Users\Inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: frontBoost.hex
  ILINK.IlinkOutputFile: frontBoost.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group project/inc
    ./: main.h stm8s_conf.h stm8s_it.h
  group project/src
    ./: main.c stm8s_it.c
  group stdPeripheralDrivers/inc
    ../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group stdPeripheralDrivers/src
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group users/inc
    ../Users/Inc/: clock.h comm.h Crc16.h escf.h ledlight.h systemStatus.h tim1PwmCtrl.h timtick.h usart.h
  group users/src
    ../Users/Src/: clock.c comm.c Crc16.c escf.c ledlight.c systemStatus.c tim1PwmCtrl.c timtick.c usart.c
